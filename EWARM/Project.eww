<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NUCLEO-F072RB_eeprom_i2c.ewp</path>
  </project>
  <batchBuild />
</workspace>
